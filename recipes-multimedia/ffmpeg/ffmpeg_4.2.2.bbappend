PACKAGECONFIG = " avcodec avformat swresample gpl"
