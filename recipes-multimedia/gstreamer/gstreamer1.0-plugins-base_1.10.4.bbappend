FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-dmabuf-sub-classable.patch"
SRC_URI += " file://0001-allocators-define-GST_CAPS_FEATURE_MEMORY_DMABUF.patch"

