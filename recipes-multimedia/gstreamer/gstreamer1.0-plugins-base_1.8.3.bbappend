PACKAGECONFIG_remove = "alsa"