#remove ne10 as per cobalt build root configuration to fix audio noise issue.
DEPENDS_remove = "ne10"
