#System can't read out correct revsion for single git with SRCREV format enabled.
#SRCREV_FORMAT = ""
#SRCREV_libunpriv = ""
