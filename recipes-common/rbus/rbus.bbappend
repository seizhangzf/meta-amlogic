#SRC_URI doesn't contain 'name' field
SRCREV_FORMAT = ""
