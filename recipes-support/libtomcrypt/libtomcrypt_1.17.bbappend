SRC_URI = "git://github.com/libtom/libtomcrypt.git;protocol=https;branch=develop"
