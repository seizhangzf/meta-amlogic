FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://for-ramdisk-autobuild-failure.patch"
