FILESEXTRAPATHS_prepend_dunfell := "${THISDIR}/xdialserver/dunfell:"
SRC_URI_append_dunfell = " file://0001-Update-gssdp-version.patch"
