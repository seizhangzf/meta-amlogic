FILESEXTRAPATHS_prepend := "${THISDIR}/files_54:"
SRC_URI += "file://v4l2.patch"
