FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-gcc-5.x-MKlib_gen.patch"
