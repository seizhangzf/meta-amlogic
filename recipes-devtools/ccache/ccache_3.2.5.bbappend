FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-some-fallthrough-comments-to-work-around-GCC-com.patch"
