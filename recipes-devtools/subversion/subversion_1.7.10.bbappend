inherit pythonnative
BUILD_CPPFLAGS += "-P"
