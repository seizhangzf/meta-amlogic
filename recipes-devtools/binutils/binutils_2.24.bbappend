FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://logical-not-parentheses.patch"
