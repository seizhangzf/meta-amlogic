FILESEXTRAPATHS_prepend_dunfell := "${THISDIR}/protobuf/dunfell:"
SRC_URI_append_dunfell = " file://0001-fix-version-script.patch"
