PACKAGECONFIG_remove_dunfell = "gupnp0.2"
PACKAGECONFIG_append_dunfell = " gupnp1.2"
